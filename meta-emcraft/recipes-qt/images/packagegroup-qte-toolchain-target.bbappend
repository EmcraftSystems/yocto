RDEPENDS_${PN} += "libmcc-dev libmcc-staticdev libcmsis-dev libsocketcan-dev wt-dev"
