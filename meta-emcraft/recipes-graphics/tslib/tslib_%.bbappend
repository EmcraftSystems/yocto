SRC_URI += "file://tslib_mt.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
