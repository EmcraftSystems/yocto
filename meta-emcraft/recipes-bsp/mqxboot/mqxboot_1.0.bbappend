COMPATIBLE_MACHINE = "(vf6-som)"

do_compile_prepend () {
		   cd ${S}
}

do_install_prepend () {
		   cd ${S}
}
