SRC_URI += "file://fbset_switch_modes.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
