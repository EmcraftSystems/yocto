KORG_ARCHIVE_COMPRESSION = "xz"

require linux-libc-headers.inc

SRC_URI[md5sum] = "1d0422cad4c6329d6d59f94e5789e368"
SRC_URI[sha256sum] = "074f17f6b76e644d0d39865733e1a6690d7a5eade678be4354da4a6510eb8c24"

